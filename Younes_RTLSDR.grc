options:
  parameters:
    author: Younes Jose
    description: Receptor FM para RTL2832U / R820T con audio estereo a 48 kHz
    generate_options: qt_gui
    id: Younes_RTLSDR
    output_language: python
    title: Radio FM - RTL-SDR
  states: {}

blocks:
- name: decim
  id: variable
  parameters:
    value: '10'
  states: {}
- name: freq_canal
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: Desplazamiento de canal (Hz)
    start: '-1e6'
    step: 10e3
    stop: 1e6
    value: 200e3
  states: {}
- name: freq_sdr
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Frecuencia central (Hz)
    start: 88e6
    step: 100e3
    stop: 108e6
    value: 98.5e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: samp_rate_decim
  id: variable
  parameters:
    value: samp_rate/decim
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-freq_canal'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_wfm_rcv_pll_0
  id: analog_wfm_rcv_pll
  parameters:
    audio_decimation: '5'
    deemph_tau: '75e-6'
    quad_rate: samp_rate_decim
  states: {}
- name: blocks_correctiq_0
  id: blocks_correctiq
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    type: complex
    name: RF
    fc: freq_sdr
    bw: samp_rate
    fftsize: '2048'
    average: '0.2'
    ymin: '-100'
    ymax: '0'
    gui_hint: 'tabs@0: 0,0,1,1'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 100e3
    decim: decim
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 20e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 'tabs@2: 0,0,1,1'
    name: '"Audio"'
    nconnections: '2'
    size: '1024'
    srate: '48000'
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate_decim
    fc: freq_sdr+freq_canal
    fftsize: '1024'
    gui_hint: 'tabs@1: 0,0,1,1'
    int_max: '0'
    name: '"Canal"'
    type: complex
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    type: fc32
    samp_rate: samp_rate
    center_freq: freq_sdr
    gain: '29.7'
    bufflen: '262144'
  states: {}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    gui_hint: 2,0,10,1
    label0: RF
    label1: Canal
    label2: Audio
    num_tabs: '3'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    value: '0.3'
    start: '0'
    stop: '1'
    step: '0.05'
    label: Volumen
    gui_hint: 12,0,1,1
  states: {}
- name: volume_0
  id: blocks_multiply_const_vxx
  parameters:
    type: float
    const: volume
  states: {}
- name: volume_1
  id: blocks_multiply_const_vxx
  parameters:
    type: float
    const: volume
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
    num_inputs: '2'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_wfm_rcv_pll_0, '0', qtgui_time_sink_x_0, '0']
- [analog_wfm_rcv_pll_0, '1', qtgui_time_sink_x_0, '1']
- [blocks_correctiq_0, '0', blocks_multiply_xx_0, '0']
- [blocks_correctiq_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_pll_0, '0']
- [low_pass_filter_0, '0', qtgui_waterfall_sink_x_0, '0']
- [soapy_rtlsdr_source_0, '0', blocks_correctiq_0, '0']
- [analog_wfm_rcv_pll_0, '0', volume_0, '0']
- [volume_0, '0', audio_sink_0, '0']
- [analog_wfm_rcv_pll_0, '1', volume_1, '0']
- [volume_1, '0', audio_sink_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
